# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Demo.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\app\inc; ..\middleware\inc; ..\driver\app_driver\inc; ..\driver\HD130_driver\inc; ..\OS\Inc; ..\Protocol\Inc; ..\main; ..\startup
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: Demo.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\hc32l136.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/src/: Buzzer.c FeedDog.c FlowMeasurement.c Interrupt_CallBack.c LCD_JC_IC.c MechanicalButton.c Sleep.c sysinit.c Valve.c Variable.c
    ../app/inc/: Communication.c
  group driver/App_Drivers
    ../driver/app_driver/src/: APP_ADC.c APP_EEPROM.c APP_IIC.c APP_LCD.c APP_Lpuart0.c APP_RTC.c
  group driver/HD130_Drivers
    ../driver/HD130_driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c interrupts_hc32l136.c lcd.c lpm.c lpt.c lpuart.c lvd.c opa.c pca.c pcnt.c reset.c rng.c rtc.c spi.c sysctrl.c timer3.c trim.c uart.c vc.c wdt.c
  group main
    ../main/: main.c
  group middleware
    ../middleware/src/: Math_Lib.c SoftwareTimer.c State.c ZLG_Queue.c
  group OS
    ../OS/Inc/: sch_cfg.h schedule.h
    ../OS/Src/: schedule.c
  group Protocol
    ../Protocol/Src/: ModuleBoardProtocol.c NBProtocol.c WM645.c
  group startup
    ../startup/: startup_hc32l136.s system_hc32l136.c
